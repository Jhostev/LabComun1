options:
  parameters:
    author: Grupo01J1A
    category: '[Grupo01]'
    copyright: Grupo01J1A
    generate_options: qt_gui
    id: Lab5
    output_language: python
    title: Compara
  states: {}

blocks:
- name: d1
  id: variable_qtgui_range
  parameters:
    label: retardo señal 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: d2
  id: variable_qtgui_range
  parameters:
    label: retardo señal 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: d3
  id: variable_qtgui_range
  parameters:
    label: retardo señal 3
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: d4
  id: variable_qtgui_range
  parameters:
    label: retardo señal demodulador
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frec señal cuadrada
    start: '0'
    step: '100'
    stop: '5000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: Ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: Laboratorio5_0
  id: Laboratorio5
  parameters:
    d: w
    fs: 1e3
    samp_rate: samp_rate
  states: {}
- name: Laboratorio5_0_0
  id: Laboratorio5
  parameters:
    d: w
    fs: 1e3
    samp_rate: samp_rate
  states: {}
- name: Laboratorio5_1
  id: Laboratorio5
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Laboratorio5_2
  id: Laboratorio5
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Laboratorio5_3
  id: Laboratorio5
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: d4
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: d2
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: d3
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: A
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: demodulada
    nconnections: '2'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}

connections:
- [Laboratorio5_0, '0', blocks_add_xx_0, '0']
- [Laboratorio5_0, '0', qtgui_time_sink_x_0, '0']
- [Laboratorio5_0_0, '0', low_pass_filter_0, '0']
- [Laboratorio5_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [Laboratorio5_1, '0', blocks_delay_0, '0']
- [Laboratorio5_2, '0', blocks_delay_1, '0']
- [Laboratorio5_3, '0', blocks_delay_2, '0']
- [analog_sig_source_x_0, '0', Laboratorio5_0, '0']
- [analog_sig_source_x_1, '0', Laboratorio5_2, '0']
- [analog_sig_source_x_2, '0', Laboratorio5_1, '0']
- [analog_sig_source_x_3, '0', Laboratorio5_3, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', Laboratorio5_0_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_delay_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_2, '0', qtgui_time_sink_x_0, '3']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_2, '0']

metadata:
  file_format: 1
