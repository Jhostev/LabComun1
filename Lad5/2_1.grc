options:
  parameters:
    generate_options: qt_gui
    id: ModulacionPWM
    output_language: python
    realtime_scheduling: '1'
    title: Grupo01J1A
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: amplitud
    start: '0'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: A_0
  id: variable_qtgui_range
  parameters:
    label: a
    start: '-2'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: offset
    start: '-2'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: 2*A
    freq: 10e3
    offset: '-A+offset'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', ModulosEfren_Compara_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ModulosEfren_Compara_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
